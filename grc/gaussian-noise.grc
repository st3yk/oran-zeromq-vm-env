options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: srsRAN noise generator
  states: {}

blocks:
- name: noise_power
  id: variable
  parameters:
    value: '-80'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: 10**(noise_power/20.0)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: 10**(noise_power/20.0)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: gNB, TX:2000, RX:2001
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: UE1, TX:2101, RX:2100
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: 'Downlink: gNB->UE'
  states: {}
- name: note_0_2_0
  id: note
  parameters:
    note: 'Uplink: UE->gNB'
  states: {}
- name: zeromq_rep_sink_downlink
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_uplink
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_downlink
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_uplink
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0, '0', zeromq_rep_sink_downlink, '0']
- [blocks_add_xx_0_0, '0', zeromq_rep_sink_uplink, '0']
- [blocks_throttle_0, '0', blocks_add_xx_0_0, '1']
- [blocks_throttle_0_0, '0', blocks_add_xx_0, '1']
- [zeromq_req_source_downlink, '0', blocks_throttle_0_0, '0']
- [zeromq_req_source_uplink, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
